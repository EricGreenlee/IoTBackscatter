options:
  parameters:
    generate_options: qt_gui
    id: USRP_visualization
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: data_bits
  id: variable
  parameters:
    value: '8'
  states: {state: disabled}
- name: encoded_val_10
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0]'
  states: {state: disabled}
- name: f_cent
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: max_preamble_err_bits
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_bits
  id: variable
  parameters:
    value: '16'
  states: {}
- name: parity_bits
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: preamble
  id: variable
  parameters:
    value: '"AAAAAAAAAAAAAAAA"'
  states: {}
- name: preamble_0
  id: variable
  parameters:
    value: '"1010101000001111"'
  states: {state: disabled}
- name: repetitions
  id: variable
  parameters:
    value: '5'
  states: {state: disabled}
- name: rf_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rx_bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sig_bw
  id: variable
  parameters:
    value: 2/symbol_dur
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(symbol_dur/(1/samp_rate))
  states: {}
- name: symbol_dur
  id: variable
  parameters:
    value: '80e-6'
  states: {}
- name: tag_freq_hz
  id: variable
  parameters:
    value: '50212'
  states: {}
- name: Decoder_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      STATE_SEARCH = 0
      STATE_HEADER = 1
      STATE_DATA = 2

      type Bit = int
      type Symbol = list[Bit]

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block

          # only default arguments here
          def __init__(self, data_bits=8, parity_bits=4, code_repetitions=5,
                       min_valid_repetitions=2):
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Decoder with Threshold',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte, np.float32],
              )

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.data_bits = data_bits
              self.parity_bits = parity_bits
              self.code_repetitions = code_repetitions
              self.min_valid_repetitions = min_valid_repetitions

              if self.data_bits > 8:
                  raise Exception("max allowed data bits is 8")

              if self.data_bits % self.parity_bits != 0:
                  raise Exception("data_bits mod parity_bits must equal 0")

              if self.min_valid_repetitions > self.code_repetitions:
                  raise Exception("cannot have higher min valid repetitons than number of repetitions")

              self.code_symbol_bits = self.data_bits + self.parity_bits
              self.code_group_len = self.code_symbol_bits * self.code_repetitions
              self.raw_bits = []
              self.low_confidence_counter = 0

          def general_work(self, input_items, output_items):
              added = 0
              to_consume = min(len(input_items[0]), len(output_items[0]))

              for i in range(to_consume):
                  bit = input_items[0][i]
                  # self.raw_bits.append(1 if bit == np.int8(1) else 0)
                  self.raw_bits.append(bit)

                  if len(self.raw_bits) == self.code_group_len:
                      # if self.raw_bits != [0,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,1,0,1,0,1,0,1,0]:
                      #     raise Exception(f'bad raw bits: {self.raw_bits}')

                      decoded = self.decode(self.raw_bits)
                      # if decoded != [0,0,0,0,1,0,1,0]:
                      #     raise Exception(f'bad decoded: {decoded}')

                      data_byte = 0
                      if decoded:
                          data_byte = self.bits_to_int(decoded)

                      # if data_byte != 10:
                      #     raise Exception(f'bad data byte: {data_byte}')

                      output_items[0][added] = data_byte
                      output_items[1][added] = self.calc_ber(self.raw_bits, data_byte) if decoded else 1.0
                      added += 1

                      self.raw_bits = []

              self.consume_each(to_consume)
              return added


          def decode(self, bits: list[Bit]) -> list[Bit] | None:
              symbol_repetitions = [bits[self.code_symbol_bits*r:self.code_symbol_bits*(r+1)]
                                      for r in range(self.code_repetitions)]
              valid_repetitions = [s for s in symbol_repetitions if self.is_valid(s)]
              counts = {}
              best_count = 0
              best_data = None
              for symbol in valid_repetitions:
                  data = symbol[0:self.data_bits]
                  key = self.bits_to_key(data)
                  if not key in counts:
                      counts[key] = 0
                  counts[key] += 1
                  if counts[key] > best_count:
                      best_count = counts[key]
                      best_data = data

              return best_data if best_count >= self.min_valid_repetitions else None


          # validate parity bits
          def is_valid(self, symbol: Symbol) -> bool:
              data = symbol[0:self.data_bits]
              checksum = [False for _ in range(self.parity_bits)]
              for offset in range(0, self.data_bits, self.parity_bits):
                  checksum = [checksum[i] ^ data[offset+i] for i in range(self.parity_bits)]

              return checksum == symbol[self.data_bits:]


          # create a unique key corresponding to the given bits
          def bits_to_key(self, bits: list[Bit]) -> int:
              k = 0
              for i in range(len(bits)):
                  k = k | (bits[i] << i)
              return k

          def bits_to_int(self, bits: list[Bit]) -> int:
              val = 0
              for i in range(len(bits)):
                  val = val | (bits[i] << (len(bits) - i - 1))
              return val

          def int_to_bits(self, val: int) -> list[Bit]:
              return [(val >> (self.data_bits - i - 1)) & 0x1 for i in range(self.data_bits)]

          def encode(self, val: int) -> list[Bit]:
              val_bits = self.int_to_bits(val)
              checksum = [0 for _ in range(self.parity_bits)]
              for offset in range(0, self.data_bits, self.parity_bits):
                  checksum = [checksum[i] ^ val_bits[offset+i] for i in range(self.parity_bits)]

              symbol = val_bits + checksum
              return symbol * self.code_repetitions

          def calc_ber(self, bits: list[Bit], expected_val: int) -> float:
              encoded = self.encode(expected_val)
              if len(bits) != len(encoded):
                  raise Exception(f"Incorrect number of bits. Expected {len(encoded)}, got {len(bits)}.")

              bit_errors = sum([0 if bits[i] == encoded[i] else 1 for i in range(len(bits))])
              return bit_errors / len(bits)
    code_repetitions: repetitions
    data_bits: data_bits
    min_valid_repetitions: '2'
    parity_bits: parity_bits
  states: {state: disabled}
- name: analog_agc3_xx_0_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '40'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: max_preamble_err_bits
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/backscatter/Documents/Backscatter/GNURadio/2026/Simple_demod_output_20260224.txt
    type: byte
  states: {}
- name: blocks_file_sink_1_1_0
  id: blocks_file_sink
  parameters:
    file: /home/ubicomp/backscatter/Greenlee/rx_files/BS_coded.txt
    type: byte
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0_1_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
    type: ccf
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, max_valid_val=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Data Filter',   # will show up in GRC
                  in_sig=[np.byte, np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.max_valid_val = max_valid_val

          def general_work(self, input_items, output_items):
              added = 0
              to_consume = min(len(input_items[0]), len(output_items[0]))

              for i in range(to_consume):
                  bit = input_items[0][i]
                  val = input_items[1][i]
                  if val <= self.max_valid_val:
                      output_items[0][added] = bit
                      added += 1

              self.consume_each(to_consume)
              return added
    max_valid_val: max_preamble_err_bits
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Preamble detector and payload extractor for backscatter signals.
      Searches for 64-bit preamble and extracts following 16-bit payload.
      Outputs to both file and QT GUI number sink.
      """

      import numpy as np
      from gnuradio import gr

      STATE_SEARCH = 0
      STATE_PAYLOAD = 1

      class blk(gr.basic_block):

          def __init__(self, preamble_hex="DEADBEEFCAFEBABE"):
              """
              Preamble detector and payload extractor

              Args:
                  preamble_hex: 64-bit preamble as hex string (16 hex characters)
              """
              gr.basic_block.__init__(
                  self,
                  name='Preamble Detector and Payload Extractor',
                  in_sig=[np.byte],
                  out_sig=[np.byte, np.float32]  # bits output, payload value output
              )

              # Convert hex preamble to bit array (64 bits)
              self.preamble_bits = self.hex_to_bits(preamble_hex)

              # Create inverted preamble for 180-degree phase detection
              self.inverted_preamble_bits = [1-b for b in self.preamble_bits]

              # State variables
              self.payload_count = 0

              # File output
              try:
                  self.output_file = open('/home/backscatter/Documents/Backscatter/GNURadio/2026/sync_payload_output.txt', 'w')
              except Exception as e:
                  print(f"Could not open output file: {e}")
                  self.output_file = None

              print(f"Preamble detector initialized with 64-bit preamble")
              print(f"Preamble hex: {preamble_hex}")

              self.start_search()

          def hex_to_bits(self, hex_string):
              """Convert hex string to list of bits (MSB first)"""
              # Remove any whitespace or 0x prefix
              hex_string = hex_string.replace(' ', '').replace('0x', '')

              bits = []
              for hex_char in hex_string:
                  val = int(hex_char, 16)
                  # Convert to 4 bits (MSB first)
                  for i in range(3, -1, -1):
                      bits.append((val >> i) & 1)
              return bits

          def general_work(self, input_items, output_items):
              """Main processing function"""
              input_bits = input_items[0]
              output_bits = output_items[0] if len(output_items) > 0 else None
              output_payload = output_items[1] if len(output_items) > 1 else None

              added = 0
              consumed = 0
              to_consume = len(input_bits)

              for i in range(to_consume):
                  bit = int(input_bits[i])
                  consumed += 1

                  if self.state == STATE_SEARCH:
                      # Shift in new bit to search buffer
                      self.search_bits = self.search_bits[1:] + [bit]

                      # Check for preamble match (normal)
                      if self.search_bits == self.preamble_bits:
                          print("Preamble found (normal phase)")
                          self.inverted = False
                          self.start_payload_extraction()

                      # Check for preamble match (inverted)
                      elif self.search_bits == self.inverted_preamble_bits:
                          print("Preamble found (inverted phase)")
                          self.inverted = True
                          self.start_payload_extraction()

                  elif self.state == STATE_PAYLOAD:
                      # Apply phase correction if needed
                      corrected_bit = bit if not self.inverted else (1 - bit)

                      self.payload_bits.append(corrected_bit)

                      if output_bits is not None and added < len(output_bits):
                          output_bits[added] = corrected_bit
                          added += 1

                      # Check if we have collected 16 bits
                      if len(self.payload_bits) == 16:
                          payload_value = self.process_payload()

                          # Send payload value to second output
                          if output_payload is not None and added < len(output_payload):
                              output_payload[added-1] = float(payload_value)

                          self.start_search()

              self.consume_each(consumed)
              return added

          def start_search(self):
              """Reset to search state"""
              self.state = STATE_SEARCH
              self.inverted = False
              self.search_bits = [0] * 64  # 64-bit rolling buffer
              self.payload_bits = []

          def start_payload_extraction(self):
              """Switch to payload extraction state"""
              self.state = STATE_PAYLOAD
              self.payload_bits = []

          def process_payload(self):
              """Process the extracted 16-bit payload"""
              # Convert bits to integer value (MSB first)
              payload_value = 0
              for i, bit in enumerate(self.payload_bits):
                  payload_value += bit * (2 ** (15 - i))

              self.payload_count += 1

              # Write to file
              if self.output_file:
                  self.output_file.write(f"Payload {self.payload_count}: ")
                  self.output_file.write(''.join(map(str, self.payload_bits)))
                  self.output_file.write(f" (Value: {payload_value})\n")
                  self.output_file.flush()

              print(f"Extracted payload {self.payload_count}: {payload_value} ({''.join(map(str, self.payload_bits))})")

              return payload_value

          def __del__(self):
              """Cleanup when block is destroyed"""
              if hasattr(self, 'output_file') and self.output_file:
                  self.output_file.close()


      # Helper function for standalone testing
      def test_preamble_detector():
          """Test function for the preamble detector"""
          # Example usage
          detector = blk(preamble_hex="DEADBEEFCAFEBABE")  # 64-bit hex preamble

          # Test data: preamble + payload
          test_bits = detector.preamble_bits + [1,0,1,1,0,0,1,0,1,0,1,0,1,1,0,0]  # 16-bit payload

          print(f"Test input: {test_bits}")

          # Simulate processing
          input_items = [np.array(test_bits, dtype=np.byte)]
          output_items = [np.zeros(len(test_bits), dtype=np.byte),
                         np.zeros(len(test_bits), dtype=np.float32)]

          detector.general_work(input_items, output_items)

      if __name__ == "__main__":
          test_preamble_detector()
    preamble_hex: preamble
  states: {state: disabled}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: sig_bw
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: sig_bw/4
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,0,1,1
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,1
    name: '"Unfiltered input"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,1,1,1
    name: '"Filtered"'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '65536'
    min: '0'
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '65536'
    min: '0'
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    max: '65536'
    min: '0'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,0,1,1
    max: '128'
    min: '-128'
    name: '"Coded"'
    type: float
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_number_sink_1_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,0,1,1
    max: '128'
    min: '-128'
    name: '"Temperature"'
    type: float
    update_time: '0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 1,1,1,1
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: preamble err bits
    label2: max preamble err bits
    name: last preamble diff
    nconnections: '2'
    size: '128'
    srate: samp_rate
    type: float
    ymax: len(preamble)
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"data"'
    size: '128'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,0,1,1
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 4,0,1,2
    name: bit error rate
    size: '128'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {state: disabled}
- name: simple_access_code_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      STATE_SEARCH = 0
      STATE_HEADER = 1
      STATE_DATA = 2
      MAX_DIFF = 127

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, preamble="", data_len_bits=8, header_len_bits=0, max_err_bits=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Preamble Detector',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte, np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.preamble = preamble
              self.data_len_bits = data_len_bits
              self.header_len_bits = header_len_bits
              self.max_err_bits = max_err_bits

              self.preamble_bits = [np.byte(c) for c in preamble]
              self.inverted_preamble_bits = [np.byte(b^1) for b in self.preamble_bits]
              self.header_half = int(self.header_len_bits / 2)

              self.start_search()

          def general_work(self, input_items, output_items):
              added = 0
              to_consume = min(len(input_items[0]), len(output_items[0]))

              for i in range(to_consume):
                  bit = input_items[0][i]
                  if self.inverted:
                      bit = np.byte(bit^1)

                  output_items[0][added] = bit
                  output_items[1][added] = self.last_diff
                  added += 1

                  if self.state == STATE_SEARCH:
                      self.search_bits = self.search_bits[-(len(self.preamble_bits) - 1):] + [bit]

                      diff_regular = diff(self.search_bits, self.preamble_bits)
                      diff_inverted = diff(self.search_bits, self.inverted_preamble_bits)
                      min_diff = min(diff_regular, diff_inverted)
                      self.last_diff = min_diff

                      if min_diff <= self.max_err_bits:
                          self.inverted = min_diff == diff_inverted
                          self.start_header()

                  elif self.state == STATE_HEADER:
                      self.header_bits.append(bit)

                      if len(self.header_bits) == self.header_len_bits:
                          len1, len2 = self.header_bits[:self.header_half], self.header_bits[self.header_half:]
                          if len1 == len2:
                              self.data_len_bits = binary_digits_to_int(len1) * 8
                              self.start_data()
                          else:
                              self.start_search()

                  elif self.state == STATE_DATA:
                      self.data_bits.append(bit)

                      if len(self.data_bits) == self.data_len_bits:
                          self.start_search()

              self.consume_each(to_consume)
              return added

          def start_search(self):
              self.state = STATE_SEARCH
              self.inverted = False
              self.search_bits = []
              self.last_diff = MAX_DIFF

          def start_header(self):
              if self.header_len_bits > 0:
                  self.state = STATE_HEADER
                  self.header_bits = []
              else:
                  self.start_data()

          def start_data(self):
              self.state = STATE_DATA
              self.data_bits = []

      def binary_digits_to_int(digits):
          return sum([v * 2 ** i for i, v in enumerate(reversed(digits))])

      def diff(bits1, bits2):
          if len(bits1) != len(bits2):
              return MAX_DIFF
          return sum([0 if bits1[i] == bits2[i] else 1 for i in range(len(bits1))])
    data_len_bits: (data_bits + parity_bits) * repetitions
    header_len_bits: '0'
    max_err_bits: max_preamble_err_bits
    preamble: preamble
  states: {state: disabled}
- name: simple_access_code_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      STATE_SEARCH = 0
      STATE_HEADER = 1
      STATE_DATA = 2

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, preamble="", data_len_bits=8, header_len_bits=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Preamble Detector',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.preamble = preamble
              self.data_len_bits = data_len_bits
              self.header_len_bits = header_len_bits

              self.preamble_bits = [np.byte(c) for c in preamble]
              self.inverted_preamble_bits = [np.byte(b^1) for b in self.preamble_bits]
              self.header_half = int(self.header_len_bits / 2)

              self.start_search()

          def general_work(self, input_items, output_items):
              added = 0
              to_consume = min(len(input_items[0]), len(output_items[0]))

              for i in range(to_consume):
                  bit = input_items[0][i]
                  if self.inverted:
                      bit = np.byte(bit^1)

                  if self.state == STATE_SEARCH:
                      self.search_bits = self.search_bits[1:] + [bit]

                      if self.search_bits == self.preamble_bits:
                          self.inverted = False
                          self.start_header()
                      elif self.search_bits == self.inverted_preamble_bits:
                          self.inverted = True
                          self.start_header()

                  elif self.state == STATE_HEADER:
                      self.header_bits.append(bit)

                      if len(self.header_bits) == self.header_len_bits:
                          len1, len2 = self.header_bits[:self.header_half], self.header_bits[self.header_half:]
                          if len1 == len2:
                              self.data_len_bits = binary_digits_to_int(len1) * 8
                              self.start_data()
                          else:
                              self.start_search()

                  elif self.state == STATE_DATA:
                      self.data_bits.append(bit)
                      output_items[0][added] = bit
                      added += 1

                      if len(self.data_bits) == self.data_len_bits:
                          self.start_search()

              self.consume_each(to_consume)
              return added

          def start_search(self):
              self.state = STATE_SEARCH
              self.inverted = False
              self.search_bits = [None for _ in self.preamble_bits]

          def start_header(self):
              if self.header_len_bits > 0:
                  self.state = STATE_HEADER
                  self.header_bits = []
              else:
                  self.start_data()

          def start_data(self):
              self.state = STATE_DATA
              self.data_bits = []

      def binary_digits_to_int(digits):
          return sum([v * 2 ** i for i, v in enumerate(reversed(digits))])
    data_len_bits: num_bits
    header_len_bits: '0'
    preamble: preamble
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: rx_bw
    center_freq0: f_cent
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rf_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [Decoder_0_1, '0', blocks_char_to_float_0_1_1, '0']
- [Decoder_0_1, '1', qtgui_time_sink_x_1, '0']
- [analog_agc3_xx_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_char_to_float_0_1_0, '0', qtgui_number_sink_1_1_0, '0']
- [blocks_char_to_float_0_1_1, '0', qtgui_number_sink_1_1_1, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_pack_k_bits_bb_0_0_0_1_0_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0_1, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_pack_k_bits_bb_0_0_0_1_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', epy_block_1, '0']
- [digital_constellation_decoder_cb_0, '0', simple_access_code_1, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0_0, '0', qtgui_time_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [epy_block_0_0, '0', Decoder_0_1, '0']
- [epy_block_0_0, '0', blocks_char_to_float_0, '0']
- [epy_block_1, '0', qtgui_number_sink_0_0, '0']
- [epy_block_1, '1', qtgui_number_sink_0_0_0, '0']
- [low_pass_filter_0_1, '0', analog_agc3_xx_0_0, '0']
- [simple_access_code_0, '0', epy_block_0_0, '0']
- [simple_access_code_0, '1', blocks_char_to_float_0_0, '0']
- [simple_access_code_0, '1', epy_block_0_0, '1']
- [simple_access_code_1, '0', qtgui_number_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
