options:
  parameters:
    generate_options: qt_gui
    id: USRP_visualization
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: data_bits
  id: variable
  parameters:
    value: '8'
  states: {state: disabled}
- name: dec
  id: variable
  parameters:
    value: '1'
  states: {}
- name: encoded_val_10
  id: variable
  parameters:
    value: '[0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0, 0, 0, 0, 0, 1, 0, 1, 0, 1, 0, 1, 0]'
  states: {state: disabled}
- name: f_cent
  id: variable
  parameters:
    value: 915.106e6
  states: {state: disabled}
- name: f_cent
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '62.8e-3'
  states: {}
- name: max_preamble_err_bits
  id: variable
  parameters:
    value: '0'
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_bits
  id: variable
  parameters:
    value: num_copies*8
  states: {state: disabled}
- name: num_copies
  id: variable
  parameters:
    value: '5'
  states: {state: disabled}
- name: parity_bits
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: preamble
  id: variable
  parameters:
    value: '"1010101010101111"'
  states: {state: disabled}
- name: preamble_0
  id: variable
  parameters:
    value: '"1010101000001111"'
  states: {state: disabled}
- name: repetitions
  id: variable
  parameters:
    value: '5'
  states: {state: disabled}
- name: rf_gain
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rx_bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: sig_bw
  id: variable
  parameters:
    value: 1/symbol_dur
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(symbol_dur/(1/samp_rate)/dec)
  states: {}
- name: symbol_dur
  id: variable
  parameters:
    value: '40e-6'
  states: {}
- name: tag_freq_hz
  id: variable
  parameters:
    value: '66500'
  states: {}
- name: Decoder_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\n\nSTATE_SEARCH = 0\nSTATE_HEADER = 1\nSTATE_DATA = 2\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n\n    # only default arguments here\n    def __init__(self, data_bits=6, parity_bits=2, code_repetitions=15, threshold=10):\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='Decoder with Threshold',   # will show up in GRC\n            in_sig=[np.byte],\n\t    #out_sig=[np.byte, np.byte],\n            out_sig=[np.byte, np.complex64],\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.data_bits = data_bits\n        self.parity_bits = parity_bits\n        self.code_repetitions = code_repetitions\n\tself.threshold = threshold\n\n        if self.data_bits % self.parity_bits != 0:\n            raise Exception(\"data_bits mod parity_bits must equal 0\")\n\n        if self.code_repetitions % 2 != 1:\n            raise Exception(\"repetitions must be odd\")\n\n\tif self.threshold > self.code_repetitions:\n\t    raise Exception(\"cannot have higher threshold than number of repetitions\")\n\n        self.code_symbol_bits = self.data_bits + self.parity_bits\n        self.code_group_len = self.code_symbol_bits * self.code_repetitions\n        self.raw_bits = []\n\tself.low_confidence_counter = 0\n\n\t#self.last_valid_time = 0\n\t#self.counter = 0\n\n\t#output_items[1][:] = 0\n\t\n\n    def general_work(self, input_items, output_items):\n        added = 0\n\n\t#print(\"lengths\")\n\t#print(len(input_items[0]))\n\t#print(len(output_items[0]))\n\t#print(input_items[0])\n\n        #to_consume = 8*self.code_repetitions\n\tto_consume = min(len(input_items[0]), len(output_items[0]))\n\t#to_consume = min(len(input_items[0]), len(output_items[0]),8*self.code_repetitions)\n\n        for i in range(to_consume):\n            bit = input_items[0][i]\n            self.raw_bits.append(bit)\n\n            if len(self.raw_bits) == self.code_group_len:               \n\t\tdecoded = self.decode(self.raw_bits)\n\t\t#print(\"raw_bits, decoded:\")\n\t\t#print(self.raw_bits)\n\t\t#print(decoded)\n\n                self.raw_bits = []\n\t\tself.consume_each(to_consume)\n\n                if not decoded:\n\t\t    #print(\"invalid decode\")\n\t\t    #print(decoded)\n\t\t    #return 0\n                    continue\n\n\t\tcount = 0\n\n\t\tdata_byte = 32*decoded[2] + 16*decoded[3] + 8*decoded[4] + 4*decoded[5] + 2*decoded[6] + decoded[7]\n\n\t\t#print(data_byte)\n\t\t\n\t\toutput_items[0][added] = data_byte\n\t\toutput_items[1][:] = time.time()-1700000000\n\t\tadded += 1\n\t\t#return 1\n\t\t#print(\"output:\")\n\t\t#print(output_items[0])\n\t\t\"\"\"\n                for b in decoded:\n\t\t    if (count < self.data_bits):\n\t\t    \n                    \toutput_items[0][added] = np.byte(b)\n\t\t    \tif added >= to_consume-1:\n\t\t\t\tself.consume_each(to_consume)\n\t\t\t\tadded = 0\n\t\t    \telse:\n                    \t\tadded += 1\n\t\t    if (count>=7):\n\t\t\tcount = 0\n\t\t    else:\n\t\t\tcount += 1\n\t\t\"\"\"\n\n        \n\t\n\n\t#print(output_items[0])\n        #return added\n\treturn added\n\n\n    def decode(self, bits):\n        bit_repetitions = [[bits[self.code_symbol_bits*r+b] for r in range(self.code_repetitions)] for b in range(self.code_symbol_bits)]\n        symbol = [self.decode_bit(b) for b in bit_repetitions]\n        if self.is_valid(symbol):\n\t    #self.last_valid_time = time.time()\n            return bits\n\n        return None\n\n    def decode_bit(self, repetitions):\n        count0 = len([b for b in repetitions if b == 0])\n        #if count0 > self.code_repetitions / 2.0:\n        #    return 0\n        #if count0 < self.code_repetitions / 2.0:\n        #    return 1\n\n\tif count0 >= self.threshold:\n\t    return 0\n\tif count0 <= self.code_repetitions - self.threshold:\n\t    return 1\n\n\t#print(self.low_confidence_counter,\" low confidence, not returning, count0: \",count0)\n\t#self.low_confidence_counter += 1\n\treturn None\n        #raise Exception(\"ambiguous number of 0s\")\n\n    def is_valid(self, symbol):\n        data = symbol[0:self.data_bits]\n        checksum = [0 for _ in range(self.parity_bits)]\n\tfor i in range(0,self.data_bits):\n\t    if data[i] == None:\n\t\treturn False\n\n        for offset in range(0, self.data_bits, self.parity_bits):\n            checksum = [checksum[i] ^ data[offset+i] for i in range(self.parity_bits)]\n\n        return checksum == symbol[self.data_bits:]\n\n"
  states: {state: disabled}
- name: Decoder_0_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\n\nSTATE_SEARCH = 0\nSTATE_HEADER = 1\nSTATE_DATA = 2\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n\n    # only default arguments here\n    def __init__(self):\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='current_time',   # will show up in GRC\n            in_sig=[],\n\t    #out_sig=[np.byte, np.byte],\n            out_sig=[np.complex64],\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        \n\t\n\n    def general_work(self, input_items, output_items):\n        \n\toutput_items[0][:] = time.time()-1700000000\n\t#out_buff\n\t\n        return len(output_items[0])\n\t\n\n"
  states: {state: disabled}
- name: Decoder_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      STATE_SEARCH = 0
      STATE_HEADER = 1
      STATE_DATA = 2

      type Bit = int
      type Symbol = list[Bit]

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block

          # only default arguments here
          def __init__(self, data_bits=8, parity_bits=4, code_repetitions=5,
                       min_valid_repetitions=2):
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Decoder with Threshold',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte, np.float32],
              )

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.data_bits = data_bits
              self.parity_bits = parity_bits
              self.code_repetitions = code_repetitions
              self.min_valid_repetitions = min_valid_repetitions

              if self.data_bits > 8:
                  raise Exception("max allowed data bits is 8")

              if self.data_bits % self.parity_bits != 0:
                  raise Exception("data_bits mod parity_bits must equal 0")

              if self.min_valid_repetitions > self.code_repetitions:
                  raise Exception("cannot have higher min valid repetitons than number of repetitions")

              self.code_symbol_bits = self.data_bits + self.parity_bits
              self.code_group_len = self.code_symbol_bits * self.code_repetitions
              self.raw_bits = []
              self.low_confidence_counter = 0

          def general_work(self, input_items, output_items):
              added = 0
              to_consume = min(len(input_items[0]), len(output_items[0]))

              for i in range(to_consume):
                  bit = input_items[0][i]
                  # self.raw_bits.append(1 if bit == np.int8(1) else 0)
                  self.raw_bits.append(bit)

                  if len(self.raw_bits) == self.code_group_len:
                      # if self.raw_bits != [0,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,1,0,1,0,1,0,1,0,0,0,0,0,1,0,1,0,1,0,1,0]:
                      #     raise Exception(f'bad raw bits: {self.raw_bits}')

                      decoded = self.decode(self.raw_bits)
                      # if decoded != [0,0,0,0,1,0,1,0]:
                      #     raise Exception(f'bad decoded: {decoded}')

                      data_byte = 0
                      if decoded:
                          data_byte = self.bits_to_int(decoded)

                      # if data_byte != 10:
                      #     raise Exception(f'bad data byte: {data_byte}')

                      output_items[0][added] = data_byte
                      output_items[1][added] = self.calc_ber(self.raw_bits, data_byte) if decoded else 1.0
                      added += 1

                      self.raw_bits = []

              self.consume_each(to_consume)
              return added


          def decode(self, bits: list[Bit]) -> list[Bit] | None:
              symbol_repetitions = [bits[self.code_symbol_bits*r:self.code_symbol_bits*(r+1)]
                                      for r in range(self.code_repetitions)]
              valid_repetitions = [s for s in symbol_repetitions if self.is_valid(s)]
              counts = {}
              best_count = 0
              best_data = None
              for symbol in valid_repetitions:
                  data = symbol[0:self.data_bits]
                  key = self.bits_to_key(data)
                  if not key in counts:
                      counts[key] = 0
                  counts[key] += 1
                  if counts[key] > best_count:
                      best_count = counts[key]
                      best_data = data

              return best_data if best_count >= self.min_valid_repetitions else None


          # validate parity bits
          def is_valid(self, symbol: Symbol) -> bool:
              data = symbol[0:self.data_bits]
              checksum = [False for _ in range(self.parity_bits)]
              for offset in range(0, self.data_bits, self.parity_bits):
                  checksum = [checksum[i] ^ data[offset+i] for i in range(self.parity_bits)]

              return checksum == symbol[self.data_bits:]


          # create a unique key corresponding to the given bits
          def bits_to_key(self, bits: list[Bit]) -> int:
              k = 0
              for i in range(len(bits)):
                  k = k | (bits[i] << i)
              return k

          def bits_to_int(self, bits: list[Bit]) -> int:
              val = 0
              for i in range(len(bits)):
                  val = val | (bits[i] << (len(bits) - i - 1))
              return val

          def int_to_bits(self, val: int) -> list[Bit]:
              return [(val >> (self.data_bits - i - 1)) & 0x1 for i in range(self.data_bits)]

          def encode(self, val: int) -> list[Bit]:
              val_bits = self.int_to_bits(val)
              checksum = [0 for _ in range(self.parity_bits)]
              for offset in range(0, self.data_bits, self.parity_bits):
                  checksum = [checksum[i] ^ val_bits[offset+i] for i in range(self.parity_bits)]

              symbol = val_bits + checksum
              return symbol * self.code_repetitions

          def calc_ber(self, bits: list[Bit], expected_val: int) -> float:
              encoded = self.encode(expected_val)
              if len(bits) != len(encoded):
                  raise Exception(f"Incorrect number of bits. Expected {len(encoded)}, got {len(bits)}.")

              bit_errors = sum([0 if bits[i] == encoded[i] else 1 for i in range(len(bits))])
              return bit_errors / len(bits)
    code_repetitions: repetitions
    data_bits: data_bits
    min_valid_repetitions: '2'
    parity_bits: parity_bits
  states: {state: disabled}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-4'
    gain: '40'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: max_preamble_err_bits
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: tag_freq_hz
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: band_reject_filter_0
  id: band_reject_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: samp_rate/2
    low_cutoff_freq: 50e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 25e3
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '32'
    type: float
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_1_1
  id: blocks_file_sink
  parameters:
    file: /home/ubicomp/backscatter/Greenlee/rx_files/BS_decoded.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_1_0
  id: blocks_file_sink
  parameters:
    file: /home/ubicomp/backscatter/Greenlee/rx_files/BS_coded.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/backscatter/Backscatter/python/src/cloud_samples/usrp_n210_20251002_141525_915MHz_0.200Msps_38.0dB_1000000samps.npy
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {state: disabled}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: loop_bw
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: loop_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 45*nfilts)
    type: ccf
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\n\n\n\n\n#class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\nclass blk(gr.basic_block):\n    #\"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='Decoder v2',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.byte,np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n\tself.raw_bits = []\n\n    def general_work(self, input_items, output_items):\n\n\t#print(len(input_items[0]))\n\t#print(len(output_items[0]))\n\n\tadded = 0\n\tto_consume = min(len(input_items[0]), len(output_items[0]))\n\n\tfor i in range(to_consume):\n\t    bit = input_items[0][i]\n\t    self.raw_bits.append(bit)\n\n\t    if len(self.raw_bits) == 15*8:\n\t\t#decoded = self.decode(self.raw_bits)\n\t\tdecoded = self.decode_simple(self.raw_bits)\n\t\tself.raw_bites = []\n\t\t#if not decoded:\n\t\t    #continue\n\n\t\toutput_items[0][:] = decoded\n\n\t\t#count = 0\n\t\t#for b in decoded:\n\t\t    #if (count < 6):\n\t\t\t#output_items[0][added] = np.byte(b)\n\n\n        #output_items[0][:] = input_items[0] \n\toutput_items[1][:] = time.time()-1700000000\n\n\tself.consume_each(to_consume)\n        #return len(output_items[0])\n\treturn added\n\n    def decode_simple(self, bits):\n\tprint(bits)\n\t#print\n\tbit_array = np.empty((15,8))\n\tdecoded_array = np.empty((15,1))\n\tprint(bit_array)\n\tfor i in range(15):\n\t    for j in range(8):\n\t\tindex = j+i*8\n\t\t#print(index)\n\t\tbit_array[i][j] = bits[index]\n\t    print(bit_array[i])\n\t    print(self.is_valid(bit_array[i]))\n\tprint(bit_array)\n\t\n\t\n\n\treturn 10\n\n    def decode(self, bits):\n        bit_repetitions = [[bits[2*r+b] for r in range(15)] for b in range(120)]\n        symbol = [self.decode_bit(b) for b in bit_repetitions]\n        if self.is_valid(symbol):\n\t    #self.last_valid_time = time.time()\n            return bits\n\n        return None\n\n    def decode_bit(self, repetitions):\n        count0 = len([b for b in repetitions if b == 0])\n        #if count0 > self.code_repetitions / 2.0:\n        #    return 0\n        #if count0 < self.code_repetitions / 2.0:\n        #    return 1\n\n\tif count0 >= self.threshold:\n\t    return 0\n\tif count0 <= self.code_repetitions - self.threshold:\n\t    return 1\n\treturn None\n\n    def is_valid(self, symbol):\n\tprint(symbol)\n\tprint(symbol[0:6])\n        data = symbol[0:6]\n        checksum = [0 for _ in range(2)]\n\tfor i in range(0,6):\n\t    if data[i] == None:\n\t\treturn False\n\n        for offset in range(0, 6,2):\n            checksum = [checksum[i] ^ data[offset+i] for i in range(2)]\n\n        return checksum == symbol[6:]\n\n"
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, max_valid_val=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Data Filter',   # will show up in GRC
                  in_sig=[np.byte, np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.max_valid_val = max_valid_val

          def general_work(self, input_items, output_items):
              added = 0
              to_consume = min(len(input_items[0]), len(output_items[0]))

              for i in range(to_consume):
                  bit = input_items[0][i]
                  val = input_items[1][i]
                  if val <= self.max_valid_val:
                      output_items[0][added] = bit
                      added += 1

              self.consume_each(to_consume)
              return added
    max_valid_val: max_preamble_err_bits
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: sig_bw
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/dec
    type: fir_filter_ccf
    width: sig_bw/4
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 500e3
    decim: dec
    gain: dec
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 500e3/4
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/dec
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/dec
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 2, 0, 1,2
    showports: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/dec
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: 2, 0, 1,2
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,1,1,1
    max: '100000000'
    name: '"New Output checker"'
    type: float
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,0,1,1
    max: '128'
    min: '-128'
    name: '"Temperature"'
    type: float
    update_time: '0.5'
  states: {state: disabled}
- name: qtgui_number_sink_1_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,0,1,1
    max: '128'
    min: '-128'
    name: '"Coded"'
    type: float
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_number_sink_1_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 0,0,1,1
    max: '128'
    min: '-128'
    name: '"Temperature"'
    type: float
    update_time: '0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 3,0,1,1
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate/dec
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 3,1,1,1
    label1: ''
    size: '1024'
    srate: samp_rate/dec
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 3,0,1,2
    label1: preamble err bits
    label2: max preamble err bits
    name: last preamble diff
    nconnections: '2'
    size: '128'
    srate: samp_rate
    type: float
    ymax: len(preamble)
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"data"'
    size: '128'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 4,0,1,2
    name: bit error rate
    size: '128'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {state: disabled}
- name: simple_access_code
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      STATE_SEARCH = 0
      STATE_HEADER = 1
      STATE_DATA = 2

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, preamble="", data_len_bits=8, header_len_bits=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Preamble Detector',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.preamble = preamble
              self.data_len_bits = data_len_bits
              self.header_len_bits = header_len_bits

              self.preamble_bits = [np.byte(c) for c in preamble]
              self.inverted_preamble_bits = [np.byte(b^1) for b in self.preamble_bits]
              self.header_half = int(self.header_len_bits / 2)

              self.start_search()

          def general_work(self, input_items, output_items):
              added = 0
              to_consume = min(len(input_items[0]), len(output_items[0]))

              for i in range(to_consume):
                  bit = input_items[0][i]
                  if self.inverted:
                      bit = np.byte(bit^1)

                  if self.state == STATE_SEARCH:
                      self.search_bits = self.search_bits[1:] + [bit]

                      if self.search_bits == self.preamble_bits:
                          self.inverted = False
                          self.start_header()
                      elif self.search_bits == self.inverted_preamble_bits:
                          self.inverted = True
                          self.start_header()

                  elif self.state == STATE_HEADER:
                      self.header_bits.append(bit)

                      if len(self.header_bits) == self.header_len_bits:
                          len1, len2 = self.header_bits[:self.header_half], self.header_bits[self.header_half:]
                          if len1 == len2:
                              self.data_len_bits = binary_digits_to_int(len1) * 8
                              self.start_data()
                          else:
                              self.start_search()

                  elif self.state == STATE_DATA:
                      self.data_bits.append(bit)
                      output_items[0][added] = bit
                      added += 1

                      if len(self.data_bits) == self.data_len_bits:
                          self.start_search()

              self.consume_each(to_consume)
              return added

          def start_search(self):
              self.state = STATE_SEARCH
              self.inverted = False
              self.search_bits = [None for _ in self.preamble_bits]

          def start_header(self):
              if self.header_len_bits > 0:
                  self.state = STATE_HEADER
                  self.header_bits = []
              else:
                  self.start_data()

          def start_data(self):
              self.state = STATE_DATA
              self.data_bits = []

      def binary_digits_to_int(digits):
          return sum([v * 2 ** i for i, v in enumerate(reversed(digits))])
    data_len_bits: num_bits
    header_len_bits: '0'
    preamble: preamble
  states: {state: disabled}
- name: simple_access_code_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      STATE_SEARCH = 0
      STATE_HEADER = 1
      STATE_DATA = 2
      MAX_DIFF = 127

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block

          def __init__(self, preamble="", data_len_bits=8, header_len_bits=0, max_err_bits=0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Preamble Detector',   # will show up in GRC
                  in_sig=[np.byte],
                  out_sig=[np.byte, np.byte]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.preamble = preamble
              self.data_len_bits = data_len_bits
              self.header_len_bits = header_len_bits
              self.max_err_bits = max_err_bits

              self.preamble_bits = [np.byte(c) for c in preamble]
              self.inverted_preamble_bits = [np.byte(b^1) for b in self.preamble_bits]
              self.header_half = int(self.header_len_bits / 2)

              self.start_search()

          def general_work(self, input_items, output_items):
              added = 0
              to_consume = min(len(input_items[0]), len(output_items[0]))

              for i in range(to_consume):
                  bit = input_items[0][i]
                  if self.inverted:
                      bit = np.byte(bit^1)

                  output_items[0][added] = bit
                  output_items[1][added] = self.last_diff
                  added += 1

                  if self.state == STATE_SEARCH:
                      self.search_bits = self.search_bits[-(len(self.preamble_bits) - 1):] + [bit]

                      diff_regular = diff(self.search_bits, self.preamble_bits)
                      diff_inverted = diff(self.search_bits, self.inverted_preamble_bits)
                      min_diff = min(diff_regular, diff_inverted)
                      self.last_diff = min_diff

                      if min_diff <= self.max_err_bits:
                          self.inverted = min_diff == diff_inverted
                          self.start_header()

                  elif self.state == STATE_HEADER:
                      self.header_bits.append(bit)

                      if len(self.header_bits) == self.header_len_bits:
                          len1, len2 = self.header_bits[:self.header_half], self.header_bits[self.header_half:]
                          if len1 == len2:
                              self.data_len_bits = binary_digits_to_int(len1) * 8
                              self.start_data()
                          else:
                              self.start_search()

                  elif self.state == STATE_DATA:
                      self.data_bits.append(bit)

                      if len(self.data_bits) == self.data_len_bits:
                          self.start_search()

              self.consume_each(to_consume)
              return added

          def start_search(self):
              self.state = STATE_SEARCH
              self.inverted = False
              self.search_bits = []
              self.last_diff = MAX_DIFF

          def start_header(self):
              if self.header_len_bits > 0:
                  self.state = STATE_HEADER
                  self.header_bits = []
              else:
                  self.start_data()

          def start_data(self):
              self.state = STATE_DATA
              self.data_bits = []

      def binary_digits_to_int(digits):
          return sum([v * 2 ** i for i, v in enumerate(reversed(digits))])

      def diff(bits1, bits2):
          if len(bits1) != len(bits2):
              return MAX_DIFF
          return sum([0 if bits1[i] == bits2[i] else 1 for i in range(len(bits1))])
    data_len_bits: (data_bits + parity_bits) * repetitions
    header_len_bits: '0'
    max_err_bits: max_preamble_err_bits
    preamble: preamble
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: f_cent
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: rx_bw
    center_freq0: f_cent
    clock_rate: '0.0'
    dev_args: '""'
    gain0: rf_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: demod_bits
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: demod_bits
  states: {state: disabled}

connections:
- [Decoder_0_1, '0', blocks_char_to_float_0_1_1, '0']
- [Decoder_0_1, '1', qtgui_time_sink_x_1, '0']
- [analog_agc3_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_const_source_x_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_reject_filter_0, '0', low_pass_filter_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_number_sink_1_1, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_1, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_char_to_float_0_1_0, '0', qtgui_number_sink_1_1_0, '0']
- [blocks_char_to_float_0_1_1, '0', qtgui_number_sink_1_1_1, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_1_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_1_0, '0', blocks_char_to_float_0_1, '0']
- [blocks_pack_k_bits_bb_0_0_0_1_0, '0', blocks_char_to_float_0_1_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_1_0, '0', blocks_file_sink_1_1_0, '0']
- [blocks_sub_xx_0, '0', blocks_complex_to_float_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', virtual_sink_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_0, '0']
- [epy_block_0_0, '0', Decoder_0_1, '0']
- [epy_block_0_0, '0', blocks_char_to_float_0, '0']
- [low_pass_filter_0, '0', analog_agc3_xx_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [simple_access_code, '0', blocks_file_sink_1_1, '0']
- [simple_access_code, '0', blocks_pack_k_bits_bb_0_0_0_1_0, '0']
- [simple_access_code_0, '0', epy_block_0_0, '0']
- [simple_access_code_0, '1', blocks_char_to_float_0_0, '0']
- [simple_access_code_0, '1', epy_block_0_0, '1']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', band_reject_filter_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle2_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', simple_access_code, '0']
- [virtual_source_0, '0', simple_access_code_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
